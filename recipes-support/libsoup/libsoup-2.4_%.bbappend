BBCLASSEXTEND_append_sota = " native"

DEPENDS_append_class-native_sota = " glib-networking-native"
